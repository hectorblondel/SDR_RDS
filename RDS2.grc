options:
  parameters:
    author: hector
    generate_options: qt_gui
    id: RDS
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Constant
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '3'
    value: '0.5'
  states: {}
- name: G
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '60'
    value: '40'
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.35'
  states: {state: disabled}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1'
    stop: '20000'
    value: '17000'
  states: {}
- name: f
  id: variable_qtgui_range
  parameters:
    label: fréquence de travail
    outputmsgname: value
    showports: 'False'
    start: '100000000'
    step: '1000'
    stop: '110000000'
    value: '104300000'
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: '1'
  states: {}
- name: num_taps
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: '100'
    value: '50'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '100'
    stop: '500000'
    value: '285000'
  states: {}
- name: t_d
  id: variable
  parameters:
    value: 1/1187.5
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    outputmsgname: value
    showports: 'False'
    start: '0'
    step: '1000'
    stop: '100000'
    value: '4000'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    min_freq: '15000'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {state: disabled}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {state: disabled}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '32000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '20000'
    low_cutoff_freq: '18000 '
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '59000'
    low_cutoff_freq: '55000 '
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Constant
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: Constant
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.decim_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, t0=0, nb_ech_par_symb=8):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.decim_block.__init__(
                  self,
                  name='Decimation',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64,np.complex64,np.complex64,np.complex64],
                  decim=nb_ech_par_symb 
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.t0 = t0
              self.nb_ech_par_symb = nb_ech_par_symb

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              output_items[0][:] = input_items[0][self.t0::self.nb_ech_par_symb]
              output_items[1][:] = input_items[0][self.t0+5::self.nb_ech_par_symb]
              output_items[2][:] = input_items[0][self.t0+10::self.nb_ech_par_symb]
              output_items[3][:] = input_items[0][self.t0+15::self.nb_ech_par_symb]
              return len(output_items[0])
    nb_ech_par_symb: '20'
    t0: '00'
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '5000'
    decim: '15'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: transition_width
    win: window.WIN_BLACKMAN
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    samp_per_symbol: '16'
    size: '10240'
    srate: '19000'
    type: float
    yunit: Diagramme de l'oeil après filtrage
  states: {}
- name: qtgui_eye_sink_x_0_0
  id: qtgui_eye_sink_x
  parameters:
    samp_per_symbol: '270'
    size: '10240'
    srate: samp_rate
    type: float
    yunit: Diagramme de l'oeuil a
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Signal SDR
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Avant translation
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: Signal SDR après filtrage
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    name: avant démodulation
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0_0_0_1_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: avant démodulation
    type: float
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '5000000'
    fc: f
    fftsize: '1024'
    type: complex
    wintype: window.WIN_KAISER
  states: {state: disabled}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: '10000000'
    fc: f
    fftsize: '1024'
    type: complex
    wintype: window.WIN_BLACKMAN
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '320'
    interp: '32'
    type: fff
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '1'
    decim: '1'
    gain: '1'
    ntaps: num_taps
    samp_rate: samp_rate/15
    sym_rate: '1187.5'
    type: fir_filter_fff
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: f
    gain0: '0'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: f
    gain0: G
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', band_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', band_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', low_pass_filter_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_xx_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_multiply_xx_0, '1']
- [band_pass_filter_0_0, '0', qtgui_freq_sink_x_0_0_0_1_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0_0, '0']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_1, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [low_pass_filter_1, '0', qtgui_eye_sink_x_0_0, '0']
- [low_pass_filter_1, '0', qtgui_freq_sink_x_0_0_0, '0']
- [low_pass_filter_1, '0', root_raised_cosine_filter_0, '0']
- [root_raised_cosine_filter_0, '0', epy_block_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_eye_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0_0_0_1, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_1, '0']
- [uhd_usrp_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']
- [uhd_usrp_source_0_0, '0', analog_pll_refout_cc_0, '0']
- [uhd_usrp_source_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [uhd_usrp_source_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
